options:
  parameters:
    author: Fran Albani
    description: This is used to generate inner_eye_relay app
    generate_options: no_gui
    id: inner_eye_relay
    output_language: python
    run_options: run
    title: Inner Eye Relay
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_path
    type: short
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '3000'
    type: short
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: input_address
  id: parameter
  parameters:
    label: Input address
    short_id: i
    type: str
    value: tcp://localhost:34000
  states: {}
- name: iq_path
  id: parameter
  parameters:
    type: str
    value: datetime.now().strftime('%Y.%m.%d_%H.%M.%S_inner_eye_relay.int16')
  states: {}
- name: output_address
  id: parameter
  parameters:
    label: Output address
    short_id: o
    type: str
    value: tcp://0.0.0.0:35000
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: output_address
    pass_tags: 'True'
    timeout: '100'
    type: short
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: input_address
    pass_tags: 'True'
    timeout: '100'
    type: short
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [zeromq_sub_source_0, '0', blocks_file_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_probe_rate_0, '0']
- [zeromq_sub_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
